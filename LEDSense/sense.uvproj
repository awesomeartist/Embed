# Keil uVision project sense.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x516RD2 SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: sense +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User\inc
  group Source Group 1
    ./: STARTUP.A51
    ./User/src/: main.c
  group DOC
    ./Doc/: readme.txt
