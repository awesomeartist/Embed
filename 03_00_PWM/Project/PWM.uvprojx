# Keil uVision project PWM.uvprojx, settings and files
target Steer_control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Steer_control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Librariers\CMSIS;..\Librariers\STM32F10x_StdPeriph_Driver\inc;..\User;..\SYS;..\User\KEY;..\User\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Librariers/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ../Librariers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group CMSIS
    ../Librariers/CMSIS/: core_cm3.c system_stm32f10x.c
  group SYS
    ../SYS/: time3.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/PWM/: bsp_pwm.c
    ../User/KEY/: bsp_key.c
